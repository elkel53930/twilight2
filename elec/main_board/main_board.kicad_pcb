# Repository elkel53930/twilight2

## KiCad design elec/main_board/main_board.kicad_pcb

Parts:
H5, H6: M2.6; M2.6 Mounting Hole

Parts:
C8, C14, C15, C25, C35, C36: GRM033R61A104KE15D; C_0201_0603Metric
C18, C49: CL32A107MPVNNNE; C_1210_3225Metric
C45, C46, C47: CL10A475KO8NNNC; C_0603_1608Metric
D12: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm
J7: B4B-ZR; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J13: B6B-ZR; JST_ZH_B6B-ZR-SM4-TF_1x06-1MP_P1.50mm_Vertical
J14: PinHeader; PinHeader_1x03_P2.54mm_Vertical
J16: Fan motor; PinHeader_1x02_P2.54mm_Vertical
Q13: DMT6008LFG; Diodes_PowerDI3333-8
Q15: IRLML6344; SOT-23
R11, R21, R22, R24, R25, R26, R27: RC0201FR-071KL; R_0201_0603Metric
R23, R35: RC0201FR-0710KL; R_0201_0603Metric
R29: 25121WF500MT4E; D_2512_6332Metric
R34, R36: 0603WAF1001T5E; R_0603_1608Metric
SW6: TS-1088-AR02016; PUSH SW 4x3mm
U17: FT231XQ-R; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U19: INA219AIDCN; SOT-23-8
U20: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
X1: CSTCE16M0V53-R0; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+5V: C8.2, C18.2, C25.2, C36.1, C45.2, C46.2, C47.2, D12.4 (VDD), J7.1, J7.3, J13.6, J14.2, R22.2, R26.2, R27.2, U17.12 (VCC), U19.4 (VS), U20.4 (VCC), U20.6 (VCC), U20.18 (AVCC); also elsewhere on the board
+BATT: C49.2, J16.2, R23.2; also elsewhere on the board
/Arm/ARM_DM: U17.9 (USBDM); also elsewhere on the board
/Arm/ARM_DP: U17.8 (USBDP); also elsewhere on the board
/Arm/BD_AD: J7.4, R36.1, U20.23 (PC0)
/Arm/BD_EN: Q15.1 (G), R35.2, U20.13 (PB1)
/Arm/LED_SIG: D12.3 (DIN), U20.10 (PD6)
/Arm/MISO: J13.3, U20.16 (PB4)
/Arm/MOSI: J13.2, U20.15 (PB3)
/Arm/MOT_PWM: Q13.4 (G), R25.2, U20.1 (PD3)
/Arm/RESET: C14.1, J13.5, R27.1, SW6.2, U20.29 (~RESET/PC6)
/Arm/RX: R24.2, U17.17 (TXD)
/Arm/SCK: J13.4, U20.17 (PB5)
/Arm/SCL: R22.1, U19.5 (SCL), U20.28 (PC5)
/Arm/SDA: R26.1, U19.6 (SDA), U20.27 (PC4)
/Arm/SERVO_SIG1: J14.1, U20.12 (PB0)
/Arm/TX: R21.1, U17.1 (RXD)
/Arm/VMON: R11.2, R23.1, U20.24 (PC1)
GND: C8.1, C15.2, C18.1, C25.1, C35.2, C36.2, C45.1, C46.1, C47.1, C49.1, D12.2 (VSS), J13.1, J14.3, Q15.2 (S), R11.1, R25.1, R29.1, R35.1, R36.2, SW6.1, U17.3 (GND), U17.13 (GND), U17.21 (GND), U19.2 (IN-), U19.3 (GND), U19.7 (A0), U19.8 (A1), U20.3 (GND), U20.5 (GND), U20.21 (GND), X1.2; also elsewhere on the board
unnamed: J7.2, R34.1
unnamed: J16.1, Q13.5 (D)
unnamed: Q15.3 (D), R34.2
unnamed: C15.1, U17.10 (3V3OUT), U17.11 (~RESET), U17.20 (VCCIO)
unnamed: C14.2, U17.18 (~DTR)
unnamed: Q13.1 (S), Q13.2 (S), Q13.3 (S), R29.2, U19.1 (IN+)
unnamed: C35.1, U20.20 (AREF)
unnamed: R24.1, U20.30 (PD0)
unnamed: R21.2, U20.31 (PD1)
unnamed: U20.7 (XTAL1/PB6), X1.3
unnamed: U20.8 (XTAL2/PB7), X1.1

Notes on the sheet:
4.7uF 16V X5R 1608 x3
D12
USB I/F for RPiCM
Timer2はMOT_PWMからの PWM信号生成に使用するため、 Arduinoのtone()は使用不可。
ブートローダー書込み用
VCC
D11
AVCC
D13
電流検出抵抗とINA219の間はケルビン接続。 電流検出抵抗はTB67H450のRSピン直近に配置。

Parts:
C17: CL10A475KO8NNNC; C_0603_1608Metric
C37, C39: CL21A106KAYNNNE; C_0805_2012Metric
C48: CL32A107MPVNNNE; C_1210_3225Metric
D1: D-060306G1/SS2/G1; LED_0603_1608Metric
D11: KT-0603R; LED_0603_1608Metric
J1: JST_ZH_B7B-ZR-SM4-TF_1x07-1MP_P1.50mm_Vertical
J2: Conn_01x22_Female; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal; Part Description 22 Position FFC, FPC Connector Contacts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
J3: PinHeader; PinHeader_1x03_P2.54mm_Vertical
J9: B2B-ZR; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module; Part Description 100 Position Connector Receptacle, Cent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
Q16: IRLML6344; SOT-23
R1, R28, R30: RC0201FR-071KL; R_0201_0603Metric; Part Description Resistor 1K M1005 1% 63mW
R32, R33: RC0201FR-071KL; R_0201_0603Metric
R37: RC0201FR-0710KL; R_0201_0603Metric
SW1, SW2, SW3, SW4: TS-1088-AR02016; PUSH SW 4x3mm
U1: 74LVC1G07SE-7; SOT-353_SC-70-5; Part Description Buffer, Non-Inverting 1 Element 1 Bit p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
U18: SL2.1A; SOP-16_3.9x9.9mm_P1.27mm
Y2: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: D1.2 (A), D11.2 (A), U1.5 (VCC); also elsewhere on the board
+3V3CM: C17.1, J1.2 (VCC), J2.22, Module1.78 (GPIO_VREF(1.8v/3.3v_Input)), Module1.84 (+3.3v_(Output)), Module1.86 (+3.3v_(Output)), R32.2, R33.2
+5V: C48.2, J3.2, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input)), U18.11 (VDD5); also elsewhere on the board
+BATT: J9.1; also elsewhere on the board
/Arm/ARM_DM: U18.5 (DM2); also elsewhere on the board
/Arm/ARM_DP: U18.6 (DP2); also elsewhere on the board
/Compute Module/BTN_DOWN: Module1.30 (GPIO6), SW1.1
/Compute Module/BTN_LEFT: Module1.26 (GPIO19), SW4.1
/Compute Module/BTN_RIGHT: Module1.28 (GPIO13), SW3.1
/Compute Module/BTN_UP: Module1.24 (GPIO26), SW2.1
/Compute Module/CAM1_C_N: J2.8, Module1.127 (CAM1_C_N)
/Compute Module/CAM1_C_P: J2.9, Module1.129 (CAM1_C_P)
/Compute Module/CAM1_D0_N: J2.2, Module1.115 (CAM1_D0_N)
/Compute Module/CAM1_D0_P: J2.3, Module1.117 (CAM1_D0_P)
/Compute Module/CAM1_D1_N: J2.5, Module1.121 (CAM1_D1_N)
/Compute Module/CAM1_D1_P: J2.6, Module1.123 (CAM1_D1_P)
/Compute Module/CAM1_D2_N: J2.11, Module1.133 (CAM1_D2_N)
/Compute Module/CAM1_D2_P: J2.12, Module1.135 (CAM1_D2_P)
/Compute Module/CAM1_D3_N: J2.14, Module1.139 (CAM1_D3_N)
/Compute Module/CAM1_D3_P: J2.15, Module1.141 (CAM1_D3_P)
/Compute Module/CAM_GPIO: J2.17, Module1.97 (Camera_GPIO)
/Compute Module/CS: J1.7 (CS), Module1.39 (GPIO8)
/Compute Module/DC: J1.6 (DC), Module1.45 (GPIO24)
/Compute Module/FSV_SIG: J3.1, Module1.55 (GPIO14)
/Compute Module/GLOBAL_EN: Module1.99 (Global_EN)
/Compute Module/LIGHT: Module1.25 (GPIO21), Q16.1 (G), R37.2
/Compute Module/MM_DM: U18.7 (DM1); also elsewhere on the board
/Compute Module/MM_DP: U18.8 (DP1); also elsewhere on the board
/Compute Module/MOSI: J1.4 (SDA), Module1.44 (GPIO10)
/Compute Module/RES: J1.5 (RES), Module1.41 (GPIO25)
/Compute Module/RUN_PG: Module1.92 (RUN_PG)
/Compute Module/SCL0: J2.20, Module1.80 (SCL0), R32.1
/Compute Module/SCLK: J1.3 (SCL), Module1.38 (GPIO11)
/Compute Module/SDA0: J2.21, Module1.82 (SDA0), R33.1
/Compute Module/USB2_N: Module1.103 (USB2_N), U18.9 (DM)
/Compute Module/USB2_P: Module1.105 (USB2_P), U18.10 (DP)
/Compute Module/nPWR_LED: Module1.95 (nPI_LED_PWR), U1.2
GND: C17.2, C37.2, C39.2, C48.1, J1.1 (GND), J2.1, J2.4, J2.7, J2.10, J2.13, J2.16, J2.19, J3.3, Module1.1 (GND), Module1.2 (GND), Module1.7 (GND), Module1.8 (GND), Module1.13 (GND), Module1.14 (GND), Module1.22 (GND), Module1.23 (GND), Module1.32 (GND), Module1.33 (GND), Module1.42 (GND), Module1.43 (GND), Module1.52 (GND), Module1.53 (GND), Module1.59 (GND), Module1.60 (GND), Module1.65 (GND), Module1.66 (GND), Module1.71 (GND), Module1.74 (GND), Module1.98 (GND), Module1.107 (GND), Module1.108 (GND), Module1.113 (GND), Module1.114 (GND), Module1.119 (GND), Module1.120 (GND), Module1.125 (GND), Module1.126 (GND), Module1.131 (GND), Module1.132 (GND), Module1.137 (GND), Module1.138 (GND), Module1.144 (GND), Module1.150 (GND), Module1.155 (GND), Module1.156 (GND), Module1.161 (GND), Module1.162 (GND), Module1.167 (GND), Module1.168 (GND), Module1.173 (GND), Module1.174 (GND), Module1.179 (GND), Module1.180 (GND), Module1.185 (GND), Module1.186 (GND), Module1.191 (GND), Module1.192 (GND), Module1.197 (GND), Module1.198 (GND), Q16.2 (S), R30.2, R37.1, SW1.2, SW2.2, SW3.2, SW4.2, U1.3 (GND), U18.12 (GND), Y2.2, Y2.4; also elsewhere on the board
unnamed: D1.1 (K), R1.1
unnamed: D11.1 (K), R28.1
unnamed: J9.2, Q16.3 (D)
unnamed: Module1.88 (+1.8v_(Output)), Module1.90 (+1.8v_(Output))
unnamed: Module1.21 (PI_nLED_Activity), R1.2
unnamed: Module1.101 (USB_OTG_ID), R30.1
unnamed: R28.2, U1.4
unnamed: C37.1, U18.14 (VDD18)
unnamed: C39.1, U18.13 (VDD33)
unnamed: U18.16 (XIN), Y2.1
unnamed: U18.15 (XOUT), Y2.3

Notes on the sheet:
USB Hub
OLED display
FUTABAサーボモータ用のTXD
Activity LED
Camera Connectors
CAM1_X_Xは等長配線
PWR LED

Parts:
C1, C13: 1005 N/M; C_0402_1005Metric
C2: 0603 50V 0.1uF; C_0201_0603Metric
C3, C4, C5, C6, C16, C19, C20, C38, C40, C41, C42, C43, C44: GRM033R61A104KE15D; C_0201_0603Metric
C7: GRM033R61A105ME44D; C_0201_0603Metric
C9, C10: CL10A105KB8NNNC; C_0603_1608Metric
C11, C12: CL21A106KAYNNNE; C_0805_2012Metric
D2: D-060306G1/SS2/G1; LED_0603_1608Metric
D3: KT-0603R; LED_0603_1608Metric
D4, D5, D6, D7: SFH4550
D13: BAS516; D_SOD-523
J4, J5: Conn_01x02; JST_ZH_B2B-ZR-SM4-TF_1x02-1MP_P1.50mm_Vertical
J6, J8: B6B-ZR; JST_ZH_B6B-ZR-SM4-TF_1x06-1MP_P1.50mm_Vertical
L1, L2: NR6045T100M; L_Changjiang_FNR6040S
LS1: SMT-0440-T-2-R
Q1, Q2: DTC114E; SOT-723
Q3, Q4, Q5, Q6: ST-1KL3A
Q7, Q8, Q9, Q10: IRLML6344; SOT-23
Q14: MMBT3904; SOT-23
R2, R3: RC0201FR-071KL; R_0201_0603Metric
R5, R6, R7, R8: 0603WAF4700T5E; R_0603_1608Metric
R10, R13, R14, R15, R16: RC0201FR-0710KL; R_0201_0603Metric
R12: 0603WAF1000T5E; R_0603_1608Metric
R31: 1005 470 1%; R_0402_1005Metric
SW5: TS-1088-AR02016; PUSH SW 4x3mm
U2, U3, U6, U7: ADCS7476; SOT-23-6
U4, U5: BD63573NUV; VSON-10-1EP_3x3mm_P0.5mm_EP1.2x2mm
U10: LSM6DSR; Bosch_LGA-14_3x2.5mm_P0.5mm
U16: FT231XQ-R; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U22: ESP32-S3-FN8; QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm
X2: 830108208709; Oscillator_SMD_ECS_2520MV-xxx-xx-4Pin_2.5x2.0mm

Connections:
+3V3: C5.2, C7.2, C9.1, C10.1, C19.1, C20.2, C38.1, C40.1, C41.1, C42.1, C43.1, C44.1, D2.2 (A), D3.2 (A), D13.1 (K), J6.1, J8.1, LS1.1, Q3.2 (C), Q4.2 (C), Q5.2 (C), Q6.2 (C), R10.2, U2.1 (VDD), U3.1 (VDD), U4.1 (PS), U4.8 (VCC), U4.9 (PWM), U5.1 (PS), U5.8 (VCC), U5.9 (PWM), U6.1 (VDD), U7.1 (VDD), U10.5 (Vdd_IO), U10.8 (Vdd), U22.2 (VDD3P3), U22.3 (VDD3P3), U22.20 (VDD3P3_RTC), U22.46 (VDD3P3_CPU), U22.55 (VDDA), U22.56 (VDDA); also elsewhere on the board
+5V: C6.2, R12.2, U16.12 (VCC); also elsewhere on the board
+BATT: C11.2, C12.2, U4.7 (VM), U5.7 (VM); also elsewhere on the board
/Compute Module/MM_DM: U16.9 (USBDM); also elsewhere on the board
/Compute Module/MM_DP: U16.8 (USBDP); also elsewhere on the board
/Micromouse/BUZZ: R31.1, U22.38 (GPIO33)
/Micromouse/CHIP_PU: C3.2, Q1.3 (C), R10.1, SW5.2, U22.4 (CHIP_PU)
/Micromouse/CS_ENC_L: J6.6, U22.21 (XTAL_32K_P)
/Micromouse/CS_ENC_R: J8.6, U22.19 (GPIO14)
/Micromouse/CS_IMU: U10.12 (CS), U22.42 (GPIO37)
/Micromouse/CWCCW_L: U5.2 (INB), U22.8 (GPIO3)
/Micromouse/CWCCW_R: U4.2 (INB), U22.10 (GPIO5)
/Micromouse/DTR: Q1.1 (B), Q2.2 (E), U16.18 (~DTR)
/Micromouse/GPIO0: C4.2, Q2.3 (C), U22.5 (GPIO0)
/Micromouse/LED_0: R3.1, U22.27 (GPIO21)
/Micromouse/LED_1: R2.1, U22.26 (GPIO20)
/Micromouse/LF_CS: U2.6 (~CS), U22.15 (GPIO10)
/Micromouse/LF_EN: Q7.1 (G), R13.2, U22.6 (GPIO1)
/Micromouse/LS_CS: U3.6 (~CS), U22.16 (GPIO11)
/Micromouse/LS_EN: Q8.1 (G), R14.2, U22.13 (GPIO8)
/Micromouse/PWM_L: U5.3 (INA), U22.7 (GPIO2)
/Micromouse/PWM_R: U4.3 (INA), U22.9 (GPIO4)
/Micromouse/RF_CS: U7.6 (~CS), U22.18 (GPIO13)
/Micromouse/RF_EN: Q10.1 (G), R16.2, U22.25 (GPIO19)
/Micromouse/RS_CS: U6.6 (~CS), U22.17 (GPIO12)
/Micromouse/RS_EN: Q9.1 (G), R15.2, U22.14 (GPIO9)
/Micromouse/RTS: Q1.2 (E), Q2.1 (B), U16.19 (~RTS)
/Micromouse/RXD: U16.17 (TXD), U22.50 (U0RXD)
/Micromouse/SPI1_MISO: J6.4, J8.4, U22.23 (GPIO17)
/Micromouse/SPI1_MOSI: J6.3, J8.3, U22.24 (GPIO18)
/Micromouse/SPI1_SCK: J6.5, J8.5, U22.22 (XTAL_32K_N)
/Micromouse/SPI2_MISO: U2.5 (SDATA), U3.5 (SDATA), U6.5 (SDATA), U7.5 (SDATA), U10.1 (SDO/SA0), U22.39 (GPIO34)
/Micromouse/SPI2_MOSI: U10.14 (SDA), U22.40 (GPIO35)
/Micromouse/SPI2_SCK: U2.4 (SCLK), U3.4 (SCLK), U6.4 (SCLK), U7.4 (SCLK), U10.13 (SCL), U22.41 (GPIO36)
/Micromouse/TXD: U16.1 (RXD), U22.49 (U0TXD)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C9.2, C10.2, C11.1, C12.1, C13.2, C16.2, C19.2, C20.1, C38.2, C40.2, C41.2, C42.2, C43.2, C44.2, J6.2, J8.2, Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q14.2 (E), R5.1, R6.1, R7.1, R8.1, R13.1, R14.1, R15.1, R16.1, SW5.1, U2.2 (GND), U3.2 (GND), U4.5 (PGND), U4.10 (GND), U4.11 (PGND), U5.5 (PGND), U5.10 (GND), U5.11 (PGND), U6.2 (GND), U7.2 (GND), U10.2 (SDx), U10.3 (SCx), U10.6 (GND), U10.7 (GND), U16.3 (GND), U16.13 (GND), U16.21 (GND), U22.57 (GND), X2.2, X2.4; also elsewhere on the board
unnamed: D2.1 (K), R3.2
unnamed: D3.1 (K), R2.2
unnamed: D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), R12.1
unnamed: D4.1 (K), Q7.3 (D)
unnamed: D5.1 (K), Q8.3 (D)
unnamed: D6.1 (K), Q9.3 (D)
unnamed: D7.1 (K), Q10.3 (D)
unnamed: D13.2 (A), LS1.2, Q14.3 (C)
unnamed: J4.1, U4.6 (OUTA)
unnamed: J4.2, L1.2
unnamed: J5.1, U5.6 (OUTA)
unnamed: J5.2, L2.2
unnamed: Q3.1 (E), R5.2, U2.3 (VIN)
unnamed: Q4.1 (E), R6.2, U3.3 (VIN)
unnamed: Q5.1 (E), R7.2, U6.3 (VIN)
unnamed: Q6.1 (E), R8.2, U7.3 (VIN)
unnamed: Q14.1 (B), R31.2
unnamed: L1.1, U4.4 (OUTB)
unnamed: L2.1, U5.4 (OUTB)
unnamed: C16.1, U16.10 (3V3OUT), U16.11 (~RESET), U16.20 (VCCIO)
unnamed: C2.1, U22.29 (VDD_SPI)
unnamed: C13.1, U22.53 (XTAL_N), X2.3
unnamed: C1.1, U22.54 (XTAL_P), X2.1

Notes on the sheet:
PhTrs are mounted on the sub-board.
0.1uF 10V X5R 0603
USB I/F for RPiCM
LEDs are mounted on the sub-board.
Motor drivers
AS5047 SPI mode = 1 (Latch at fall edges)
USB-Serial & Writer
IMU
LSM6DSR SPI mode = 3 (Latch at rise edges)
Processor
Wall sensor PhTrs
Encoders
Wall sensor LEDs
Indicators
ADCS7476 SPI mode = 3 (Latch at rise edges)

Parts:
BT1: 1000mAh LiPo 2S; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
C21, C22, C23, C30, C31, C32: CC0603KRX7R9BB104; C_0603_1608Metric
C24, C29: CL21A106KAYNNNE; C_0805_2012Metric
C26, C27, C28: CL10A106KP8NNNC; C_0603_1608Metric
C33, C34: CL10A105KB8NNNC; C_0603_1608Metric
D8: 1N5819WS; D_SOD-323
D9: D-060306G1/SS2/G1; LED_0603_1608Metric
D10: KT-0603R; LED_0603_1608Metric
J10: MJ-179PH; PJ-002A
Q11, Q12: DMT6008LFG; Diodes_PowerDI3333-8
R4: RC0201FR-071KL; R_0201_0603Metric
R9: 0603WAF1501T5E; R_0603_1608Metric
R17: RC0201FR-0710KL; R_0201_0603Metric
R18: 0603WAF1001T5E; R_0603_1608Metric
R19: 0603WAF3300T5E; R_0603_1608Metric
R20: 0603WAF100JT5E; R_0603_1608Metric
U11: OKL-T/6-W12N-C; OKL-T&slash_6-W12N-C_MUR
U12: XC6221B332MR; SOT-23-5
U13, U15: LM74700QDBVRQ1; SOT-23-6
U14: MCP73213T-A6SI/MF; DFN-10-1EP_3x3mm_P0.5mm_EP1.58x2.35mm

Connections:
+3V3: C28.2, U12.5 (VOUT); also elsewhere on the board
+5V: C26.2, C27.2, C29.1, D8.2 (A), U11.4 (Vout), U11.5 (Sense), U12.1 (VIN), U12.3 (CE); also elsewhere on the board
+BATT: C23.2, C24.2, C32.2, D8.1 (K), Q11.5 (D), Q12.5 (D), R17.2, U11.2 (Vin), U13.4 (CATHODE), U15.4 (CATHODE); also elsewhere on the board
/Power/EXT_PWR: C21.2, C22.2, C33.2, D10.2 (A), J10.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), U13.3 (EN), U13.6 (ANODE), U14.1 (VDD), U14.2 (VDD)
GND: BT1.2 (-), C21.1, C23.1, C24.1, C26.1, C27.1, C28.1, C29.2, C30.1, C32.1, C33.1, C34.1, D9.1 (K), J10.2, J10.3, R9.1, R20.2, U11.1 (ON/OFF), U11.3 (GND), U11.7 (GND), U12.2 (GND), U13.2 (GND), U14.8 (VSS), U14.9 (VSS), U14.11 (EP), U15.2 (GND); also elsewhere on the board
unnamed: BT1.1 (+), C30.2, C31.2, C34.2, Q12.1 (S), Q12.2 (S), Q12.3 (S), U14.3 (VBAT), U14.4 (VBAT), U15.3 (EN), U15.6 (ANODE)
unnamed: D9.2 (A), R17.1
unnamed: D10.1 (K), R4.2
unnamed: Q11.4 (G), U13.5 (GATE)
unnamed: Q12.4 (G), U15.5 (GATE)
unnamed: R18.2, R19.1
unnamed: R19.2, R20.1
unnamed: R18.1, U11.6 (Trim)
unnamed: C22.1, U13.1 (VCAP)
unnamed: R9.2, U14.10 (PROG)
unnamed: R4.1, U14.7 (STAT)
unnamed: C31.1, U15.1 (VCAP)

Notes on the sheet:
Power management
5V Max6A
Charge current is aprox 800mA
Power supply
